# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARM_LIBC, __RTTHREAD__, STM32F103xE
  c include: applications;.;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Core\Inc;board\ports;drivers;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\none-gcc;board\CubeMX_Config\Drivers\CMSIS\Device\ST\STM32F1xx\Include;board\CubeMX_Config\Drivers\CMSIS\Include;board\CubeMX_Config\Drivers\STM32F1xx_HAL_Driver\Inc;board\CubeMX_Config\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    board/CubeMX_Config/Core/Src/: main.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c showmem.c div0.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/src/: ringblk_buf.c pipe.c ringbuffer.c completion.c dataqueue.c waitqueue.c workqueue.c
  group Drivers
    board/CubeMX_Config/Core/Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
    board/startup/arm/: startup_stm32f103xe.s
    drivers/: drv_gpio.c drv_common.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    rt-thread/src/: object.c idle.c ipc.c components.c scheduler.c timer.c memheap.c mem.c kservice.c clock.c mempool.c thread.c irq.c device.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: syscalls.c mem_std.c libc.c
    rt-thread/components/libc/compilers/common/: time.c stdlib.c
  group Libraries
    board/CubeMX_Config/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio.c
